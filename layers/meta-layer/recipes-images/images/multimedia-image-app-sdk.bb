require multimedia-image-app.bb

inherit populate_sdk populate_sdk_qt5
