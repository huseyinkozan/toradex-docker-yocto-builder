require multimedia-image.bb

export IMAGE_BASENAME = "Multimedia-Image-Decoder"

IMAGE_INSTALL += " \
    app \
"
