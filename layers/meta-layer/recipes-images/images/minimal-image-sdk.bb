require minimal-image.bb

inherit populate_sdk populate_sdk_qt5
